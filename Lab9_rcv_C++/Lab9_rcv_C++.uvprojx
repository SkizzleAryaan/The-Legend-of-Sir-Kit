# Keil uVision project Lab9_rcv_C++.uvprojx, settings and files
target Lab 9 receiver (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab9_C++
  c flags: Optim=2 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup_TM4C123.s main.cpp PLL.cpp ST7735.cpp FIFO.cpp UART.cpp
software components: CMSIS:CORE 5.6.0
