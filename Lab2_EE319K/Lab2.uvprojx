# Keil uVision project Lab2.uvprojx, settings and files
target Lab2 (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lab2
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s Lab2.c
  group Object
    E:/Box/Box Sync/EE319K_Lectures/LabSolutionsKeil5/Lab2_EE319K-sol/: lab2grader.o pll.o st7735.o uart.o
software components: CMSIS:CORE 5.6.0
